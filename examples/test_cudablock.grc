options:
  parameters:
    generate_options: qt_gui
    id: test_cudablock
    output_language: python
    title: Test CUDA Block
  states: {}

blocks:
- name: k
  id: variable_qtgui_range
  parameters:
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: cudademo_multiply_const_0
  id: cudademo_multiply_const
  parameters:
    k: k
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', cudademo_multiply_const_0, '0']
- [cudademo_multiply_const_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
